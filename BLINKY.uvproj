# Keil uVision project BLINKY.uvproj, settings and files
target Simulator (MCS-51)
  device: P89C51RD2xx NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: BLINKY
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: BLINKY.C
  group Documentation
    ./: ABSTRACT.TXT
target MCBx51: 8xC51Rx (MCS-51)
  device: 8xC51RD+ NXP (founded by Philips)
  cpu: as above
  output: BLINKY
  c flags: Optimize=8 SizeSpeed=1
